require control-common.inc

SRC_URI += " \
    file://antennactrl.in \
    file://antenna.c \
"

TARGET = "antenna"
