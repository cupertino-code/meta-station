require crsf-bridge.inc

CONN_PARAMS = "-c ${STATION_IP} -p ${CRSF_PORT}"
