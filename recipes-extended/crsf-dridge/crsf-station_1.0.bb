require crsf-bridge.inc

CONN_PARAMS = "-t -s -p ${CRSF_PORT}"
