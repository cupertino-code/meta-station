FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-fbdevsink-Add-parameters-for-picture-position-in-the.patch \
"
