PACKAGECONFIG:append = " libv4l2"
