FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Revert-media-adv7180-Default-to-the-first-valid-inpu.patch \
    file://ikconfig.cfg \
"
